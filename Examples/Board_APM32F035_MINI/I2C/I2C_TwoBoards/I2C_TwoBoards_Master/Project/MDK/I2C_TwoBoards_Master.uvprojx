# Keil uVision project I2C_TwoBoards_Master.uvprojx, settings and files
target APM32F035 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F035C8 Geehy
  pack: Geehy.APM32F035_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2C_TwoBoards_Master
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BOARD_APM32F035_MINI,APM32F035
  c include: ..\..\..\..\..\..\..\Libraries\APM32F035_StdPeriphDriver\inc;..\..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F035\Include;..\..\..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\..\..\Boards\Board_APM32F035_MINI\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Source/: system_apm32f035.c
    ../../../../../../../Libraries/Device/Geehy/APM32F035/Source/arm/: startup_apm32f035.s
  group StdPeriphLib
    ../../../../../../../Libraries/APM32F035_StdPeriphDriver/src/: apm32f035_adc.c apm32f035_can.c apm32f035_comp.c apm32f035_crc.c apm32f035_dbg.c apm32f035_dma.c apm32f035_eint.c apm32f035_fmc.c apm32f035_gpio.c apm32f035_i2c.c apm32f035_iwdt.c apm32f035_m0cp.c apm32f035_misc.c apm32f035_ob.c apm32f035_opa.c apm32f035_pmu.c apm32f035_rcm.c apm32f035_rtc.c apm32f035_spi.c apm32f035_syscfg.c apm32f035_tmr.c apm32f035_usart.c apm32f035_wwdt.c
  group Boards
    ../../../../../../../Boards/: board.c
    ../../../../../../../Boards/Board_APM32F035_MINI/src/: bsp_delay.c
  group Application
    ../../Source/: main.c apm32f035_int.c
