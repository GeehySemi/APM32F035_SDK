# IAR project SPI_TwoBoards_Master.ewp, settings and files
configuration APM32F035 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F035x8 Geehy APM32F035x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32F035_MINI; APM32F035x8
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Boards; ..\..\..\..\..\..\..\Boards\Board_APM32F035_MINI\inc; ..\..\Include; ..\..\..\..\..\..\..\Libraries\APM32F035_StdPeriphDriver\inc; ..\..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F035\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_TwoBoards_Master.srec
  ILINK.IlinkOutputFile: SPI_TwoBoards_Master.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f035_int.c main.c
  group Boards
    ../../../../../../../Boards/: board.c
    ../../../../../../../Boards/Board_APM32F035_MINI/src/: bsp_delay.c
  group CMSIS
    ../../../../../../../Libraries/Device/Geehy/APM32F035/Source/iar/: startup_apm32f035.s
    ../../Source/: system_apm32f035.c
  group StdPeriphLib
    ../../../../../../../Libraries/APM32F035_StdPeriphDriver/src/: apm32f035_adc.c apm32f035_can.c apm32f035_comp.c apm32f035_crc.c apm32f035_dbg.c apm32f035_dma.c apm32f035_eint.c apm32f035_fmc.c apm32f035_gpio.c apm32f035_i2c.c apm32f035_iwdt.c apm32f035_m0cp.c apm32f035_misc.c apm32f035_ob.c apm32f035_opa.c apm32f035_pmu.c apm32f035_rcm.c apm32f035_rtc.c apm32f035_spi.c apm32f035_syscfg.c apm32f035_tmr.c apm32f035_usart.c apm32f035_wwdt.c
